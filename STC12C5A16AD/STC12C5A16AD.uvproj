# Keil uVision project STC12C5A16AD.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: STC12C5A16AD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC12C5A16AD
  asm include: ..\STC12C5A16AD
  group Source Group 1
    ./: Main.c EEPROM_Iap.c HardWare.c Motor.c State.c Automation.c Data.c
